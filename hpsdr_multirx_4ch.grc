<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hpsdr_multirx</value></param>
<param><key>author</key><value>Nathaniel Frissell W2NAF</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Records multiple spectrum chunks to disk</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>HPSDR MultiRX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_stamp</value></param>
<param><key>value</key><value>datetime.now().strftime("%Y.%m.%d.%H.%M.%S") </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>metadata</value></param>
<param><key>value</key><value>{'call':'W2NAF','grid':'&lt;6-digit-grid&gt;','rx':'Red Pitaya','ant':'DXE RF-PRO-1B'}</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_0</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>3.33e6</value></param>
<param><key>value0</key><value>'CHU_3300'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_1</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>3.596e6</value></param>
<param><key>value0</key><value>'HAM_3596'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_2</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>7.096e6</value></param>
<param><key>value0</key><value>'CHU_7850'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_3</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>7.096e6</value></param>
<param><key>value0</key><value>'HAM_7096'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_4</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>14.67e6</value></param>
<param><key>value0</key><value>'CHU_14670'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_5</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>14.096e6</value></param>
<param><key>value0</key><value>'HAM_14096'</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>rx_6</value></param>
<param><key>field0</key><value>label</value></param>
<param><key>field1</key><value>frequency</value></param>
<param><key>value1</key><value>10.05e6</value></param>
<param><key>value0</key><value>'WWV_10050'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timestamp_iso</value></param>
<param><key>value</key><value>datetime.utcnow().isoformat()+"Z"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>working_dir</value></param>
<param><key>value</key><value>"/media/icerx/icerx/hf_data/"</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>0.95</value></param>
<param><key>freq</key><value>-1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>datetime</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_sink</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_sink_0</value></param>
<param><key>metadata</key><value>metadata</value></param>
<param><key>center_freqs</key><value></value></param>
<param><key>channel0</key><value>rx_0.label</value></param>
<param><key>channel1</key><value>rx_1.label</value></param>
<param><key>channel2</key><value>rx_2.label</value></param>
<param><key>channel3</key><value>rx_3.label</value></param>
<param><key>channel4</key><value>rx_4.label</value></param>
<param><key>channel5</key><value>rx_5.label</value></param>
<param><key>channel6</key><value>rx_6.label</value></param>
<param><key>is_continuous</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>top_level_dir</key><value>working_dir</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_cadence_ms</key><value>1000</value></param>
<param><key>checksum</key><value>False</value></param>
<param><key>compression_level</key><value>0</value></param>
<param><key>ignore_tags</key><value>False</value></param>
<param><key>input</key><value>fc32</value></param>
<param><key>marching_periods</key><value>True</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>nchan</key><value>7</value></param>
<param><key>sample_rate_denominator</key><value>1</value></param>
<param><key>sample_rate_numerator</key><value>int(rx_samp_rate)</value></param>
<param><key>start</key><value>"nowish"</value></param>
<param><key>stop_on_skipped</key><value>False</value></param>
<param><key>subdir_cadence_s</key><value>3600</value></param>
<param><key>uuid</key><value></value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>hpsdr_hermesNB</key>
<param><key>id</key><value>hpsdr_hermesNB_0</value></param>
<param><key>AlexRA</key><value>0xa0</value></param>
<param><key>AlexHPF</key><value>0x00</value></param>
<param><key>AlexTA</key><value>0</value></param>
<param><key>AlexLPF</key><value>0x10</value></param>
<param><key>Intfc</key><value>"enp2s0"</value></param>
<param><key>CkS</key><value>"0xF0"</value></param>
<param><key>MACAddr</key><value>"*"</value></param>
<param><key>num_outputs</key><value>7</value></param>
<param><key>PTTTx</key><value>1</value></param>
<param><key>PTTRx</key><value>1</value></param>
<param><key>Rx0F</key><value>int(rx_0.frequency)</value></param>
<param><key>Rx1F</key><value>int(rx_1.frequency)</value></param>
<param><key>Rx2F</key><value>int(rx_2.frequency)</value></param>
<param><key>Rx3F</key><value>int(rx_3.frequency)</value></param>
<param><key>Rx4F</key><value>int(rx_4.frequency)</value></param>
<param><key>Rx5F</key><value>int(rx_5.frequency)</value></param>
<param><key>Rx6F</key><value>int(rx_6.frequency)</value></param>
<param><key>Rx7F</key><value>10000000</value></param>
<param><key>RxPre</key><value>0</value></param>
<param><key>RxSmp</key><value>rx_samp_rate</value></param>
<param><key>TxF</key><value>10000000</value></param>
<param><key>TxDrive</key><value>0</value></param>
<param><key>PTTmode</key><value>0</value></param>
<param><key>Verbose</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>000000</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>'{!s} MHz'.format(rx_0.frequency*1e-6)</value></param>
<param><key>label2</key><value>'{!s} MHz'.format(rx_1.frequency*1e-6)</value></param>
<param><key>label3</key><value>'{!s} MHz'.format(rx_2.frequency*1e-6)</value></param>
<param><key>label4</key><value>'{!s} MHz'.format(rx_3.frequency*1e-6)</value></param>
<param><key>label5</key><value>'{!s} MHz'.format(rx_4.frequency*1e-6)</value></param>
<param><key>label6</key><value>'{!s} MHz'.format(rx_5.frequency*1e-6)</value></param>
<param><key>label7</key><value>'{!s} MHz'.format(rx_6.frequency*1e-6)</value></param>
<param><key>name</key><value>Received Spectrum</value></param>
<param><key>nconnections</key><value>7</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_0.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_0.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_1.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_1.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_2.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_2.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_2</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_3.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_3.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_3</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_4.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_4.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_4</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_5.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_5.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_5</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>rx_6.frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>rx_6.label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>hpsdr_hermesNB_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_3</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_4</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_5</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
</flow_graph>
